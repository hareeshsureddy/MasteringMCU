# Keil uVision project gpio_driver.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio_driver
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Driver
    ./Driver/: hal_gpio_driver.c hal_gpio_driver.h
  group UserApp
    ./UserApp/: led.c led.h
software components: CMSIS:CORE 5.6.0, Device:CubeMX 1.0.0
